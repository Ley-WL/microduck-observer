# Repository Ley-WL/microduck-observer

File README.md:

# MicroDuck Observer

面向 MicroDuck 实机的观测、标定与控制平台。将网页调试、Android 蓝牙遥控、传感器采集、舵机执行和 ONNX 策略运行统一接入 Rust 控制后端，让界面显示的状态、模型使用的反馈和机器人执行的命令来自同一条控制链路。

本仓库维护机器人端服务、Web 工作台、模型运行合同及实测证据。Android App 在独立项目 [DuckLink](https://github.com/Ley-WL/ducklink) 中维护。

## 信息与遥控说明

### 设备信息

Wi-Fi、SSH 登录、网页调试入口、DuckLink 下载二维码及开源项目地址。

### 行走模式

默认键位与起身、行走、头部控制、动作技能及急停操作。蓝灯常亮表示手柄已连接，自定义动作以「手柄设置」为准。

### 轮滑模式

装轮预备、轮滑操控、蹲滑与站起、跌倒恢复及退出操作。轮滑功能需安装相应模型。

## 手柄自定义控制

侧栏「手柄设置」支持8个动作键自定义、取消绑定及恢复默认，网页与板端实体手柄共用持久化配置；固定急停/停止及起身长按保留。当前为本地实现，未部署实机，见 [手柄映射说明](docs/gamepad-bindings.md)。

## 模型管理

侧栏独立「模型管理」页面支持显式模型选择、默认执行模板、完整metadata和部分官方manifest导入、上一版本回退，姿态工作台保持原布局。同合同的新权重无需重编后端；停止控制后校验与预热，导入不自动启用。当前为本地实现，尚未部署实机。操作、接口及验证方法见 [模型管理说明](docs/model-registry.md)。

## 功能规划

- [自主行动功能规划](docs/autonomous-action-plan.md)：2026-10-19确认，第一版模式切换、人工接管、6秒限时起身及后续感知路线；尚未实现。

## 硬件设计资料

硬件工程、BOM、加工文件、效果图与设计检查统一存放在 [hardware/](hardware/README.md)，后续硬件模块也从该目录继续。当前电源Hub为 [Rev N / ECO1无开关＋C1版本](hardware/power-hub/README.md)，内含立创EDA、KiCad源文件、Gerber及采购清单；源检查通过，立创客户端与实物验证状态见版本说明。实测主记录继续维护在 [docs/实测记录/](docs/实测记录/README.md)。

## 界面预览

### Observer 主控工作台

将 3D 姿态、IMU 曲线、网页虚拟手柄与 15 个舵机反馈放在同一工作台。中央保留 3D 视图和可读的手柄控制区；高度不足时控制区滚动，窄屏按列重排，手柄改用分区布局，避免文字和按钮被强行缩小。

截图来自 **2026-10-14 最新 Web 源码**本地页面，浏览器视口 **1920×1080 CSS px、100% 缩放、DPR 1**，图片也是1920×1080。处于未连接状态，3D 是参考模型，曲线和关节数值等待设备反馈，动作按钮禁用。另已检查 [1280×720](docs/validation/20261014-gamepad-layout/1280x720.jpg)、[1366×768](docs/validation/20261014-gamepad-layout/1366x768.jpg) 和 [390px 窄屏](docs/validation/20261014-gamepad-layout/390x844.jpg)；窄屏截图为完整滚动页面。

网页手柄支持鼠标和多指触控：左摇杆行走 / 转向、右摇杆控制头部，松开归零。当前按键如下：

| 按键 | 网页功能 |
| --- | --- |
| A / X / Y | 站立 / 坐下 / 倒地起身 |
| B | 停止保持 |
| Back | 急停卸力；手柄外另保留独立急停按钮 |
| LB / RB | 一键演示（再次取消） / 拾取；RT嘎叫 |
| 十字键上 / 左 / 右 / 下 | 舞蹈 / 左脚踢球 / 右脚踢球 / 自主行动；左右踢球已本地接入，需主板同步新服务和模型，上下仍预留 |
| Start | 预留，暂不执行动作 |

翻滚入口保留在“按键说明与诊断”中。网页完整身体与头部控制需要配套 Rust 后端；当前手柄改动仅完成本地开发，未部署主板或通过实机验收。物理手柄配置与按键差异见 [手柄使用说明](docs/GAMEPAD.md)。

### DuckLink 控制 App

横屏操作页采用左侧行走轮盘、中间动作技能、右侧头部轮盘；顶部显示连接状态、电量与急停，底部提供速度和身体姿态。倒地起身是技能就绪入口，“嘎一下”独立提供嘴部与叫声控制。设备页支持多设备连接与切换、Observer 版本查看和 OTA 更新。

截图为已发布的 App **0.9.61** 在 Android 模拟器中的未连接界面，屏幕 **2160×1240 px、440 dpi**（约785×451 dp）；图中含安卓导航区域。以上截图用于展示各自注明版本的界面，不代表整机动作验收结果。

## 重构重点

| 重点 | 当前实现 |
| --- | --- |
| 统一控制后端 | HTTP、WebSocket 与 BLE 在同一 Rust 主服务内接入，共用动作状态、控制会话和硬件反馈，移除旧 Python 服务与蓝牙转发控制链路。 |
| 串口唯一拥有者 | 舵机采集、目标写入、使能、卸力和校准由同一个总线拥有者串行处理，网页、App 和推理任务不另开舵机串口。 |
| 模型合同显式化 | ONNX 权重与 metadata 配套，核对哈希、观测维度、关节顺序、归一化和执行配置；动作历史、滤波、增益与切换按具体模型合同处理。 |
| 真实反馈驱动显示 | 3D 关节使用实际编码器反馈；IMU、关节、系统与日志独立维护时间戳、序号、有效性及过期状态。页面接收心跳不会把旧传感器数据刷新为实时。 |
| 标定与设置统一持久化 | Web 和 App 共用主板保存的关节零位、方向、IMU 参考、安装轴向及独立模型增益；共享标定使用 revision 防止并发覆盖。 |
| 系统权限隔离 | Wi-Fi 与关机/重启由受限 Rust 辅助服务通过 Unix socket 提供，主控制服务无需 root 权限。 |
| 可验证发布 | 独立 release、候选只读核查、文件哈希验证、原子切换与回滚；升级保留现有模型、标定、增益和 BLE 身份。网页资源可单独更新，不重启控制服务。 |

## 系统架构

```mermaid
flowchart TB
    Web["Web 工作台<br/>Vue 3 · TypeScript · Three.js · ECharts"]
    App[DuckLink Android App]
    Gamepad["T4 Nova Lite 手柄<br/>本地开发 · 待实测"]
    Gamepad -->|BlueZ HID / Linux evdev| API
    Web <-->|HTTP / WebSocket| API
    App <-->|认证加密 BLE · BlueZ| API

    subgraph Board[机器人主板 · Linux ARM64]
        API["Rust 主服务<br/>Axum / Tokio · 控制会话与动作入口"]
        Telemetry["遥测缓存<br/>最新样本 · 时间戳 · 有效性 · 日志"]
        Bus["舵机总线唯一拥有者<br/>反馈读取 · 目标写入 · 校准 · 卸力"]
        Policy["模型运行器<br/>ONNX Runtime CPU · 模型合同 · 技能切换"]
        IMU[IMU 独立采集线程]
        State["持久状态<br/>共享标定 · 模型增益 · BLE 身份"]
        Helpers["受限 Rust 辅助服务<br/>Wi-Fi 管理 · 系统电源"]
        API <-->|状态订阅| Telemetry
        API -->|显式控制命令| Bus
        Bus <-->|观测与目标| Policy
        Bus -->|关节反馈| Telemetry
        IMU --> Telemetry
        IMU -->|姿态与角速度| Policy
        API <--> State
        Policy -->|读取执行配置| State
        API <-->|Unix socket| Helpers
    end

    Bus <-->|TTL UART · 1 Mbps| Servos[15 个 HD1910 舵机]
    Sensor[MS901M UART IMU] --> IMU
    Files[ONNX + metadata] --> Policy
```

**控制链路。** 网页、App 和已配置的物理手柄发出意图，服务检查当前任务与控制会话，再由总线拥有者执行。停止保持与卸力是不同操作；方向控制携带会话和递增序号，过期方向命令归零。动作、使能与模型推理由明确的用户操作启动，打开页面或恢复连接不会自动启动运动。

**模型链路。** 当前模型常用 61 维观测、14 维动作，嘴部为独立舵机控制。原生技能运行路径在控制循环中完成反馈、观测、推理与目标写入；兼容路径使用独立推理线程和最新结果槽。两条路径按各自合同执行，不将所有模型强行套用同一种滤波、增益或切换方式。机械范围、编码转换及故障处理集中在机器人端，客户端不重复实现策略。

**观测链路。** IMU 独立采集，关节反馈与模型控制共用串口拥有者，服务对外发布主题化遥测。WebSocket 按展示需要订阅最新数据，HTTP 提供元信息、快照、标定和控制接口。硬件采集频率、模型执行频率与浏览器展示频率分别管理；慢客户端不会要求服务积压全部传感器历史帧。

**运行与工具。** 机器人主服务、Wi-Fi 和电源辅助程序均为 Rust；推理使用原生 ONNX Runtime 动态库。Python 仅用于打包、部署、只读分析及部分测试工具，不作为机器人控制服务运行。音频调用系统 ALSA 播放器；可选摄像头由 Rust Observer 管理 V4L2/FFmpeg 子进程，与主服务共用 systemd 单元及 HTTP 端口，不运行 Python 摄像头服务。摄像头开关默认关闭，选择保存在主板；当前部署状态见实测记录。

## 主要功能

- **观测工作台：** 3D 身体姿态与 15 关节反馈、Roll/Pitch/Yaw、IMU 曲线、舵机电压/温度/电流/状态、CPU/内存/温度与部署版本。
- **标定：** 关节显示零位与方向、IMU 安装方向和参考姿态、Roll/Pitch 归零、显式硬件中位校准。显示标定与 EEPROM 写入分别处理。
- **实机控制：** 坐下预备、站立接行走、双摇杆网页手柄、速度设置、倒地起身、拾取、翻滚、左右脚踢球、零位，以及主板扬声器配合张闭嘴的“嘎一下”。
- **主板直连手柄（开发版）：** Linux evdev 输入复用控制后端；App BLE 与手柄连接可共存，显式动作获取控制权。物理手柄以双摇杆回中后的 LB+A 站立、LB+Y 倒地起身，Back 全局卸力。默认关闭，蓝牙配对、设备映射和双连接稳定性待实测，详见 [配置与验收要求](docs/GAMEPAD.md)。
- **诊断：** 控制状态与技能进度、反馈暂停、故障帧和会话记录、串口收发证据、日志筛选及 JSONL 导出。
- **连接与管理：** Web 自动重连及断线原因、BLE 绑定与认证、Wi-Fi 管理、Web 地址获取、确认后的主板关机/重启。

功能已接入服务不等于对应动作已在每种装配和姿态下通过验收；目前倒地起身和部分运动效果仍有用户反馈问题。

## 硬件 BOM 与接入概况

下表为当前实物配置摘要，不是完整机械采购表。针脚、电平、供电和改焊细节以对应实测页为准。

| 部件 | 数量 | 配置与用途 | 接入 / 实测说明 |
| --- | ---: | --- | --- |
| Radxa ZERO 3W | 1 | RK3566、2GB RAM、无 eMMC，microSD 启动；Linux ARM64 主控 | 已部署 Rust 服务，Wi-Fi / BLE 实机使用。见 [主板与接线](docs/实测记录/01-主板与接线.md)。 |
| Robot HAT | 1 | 电源、TTL 舵机收发与外设连接 | 当前舵机 UART2 `/dev/ttyS2`、外接 IMU UART9 `/dev/ttyS9`；接插件与改焊问题单独记录。见 [HAT 实测](docs/实测记录/07-HAT实测.md)。 |
| 飞特 HD1910 舵机 | 15 | 左腿 20–24、右腿 10–14、头颈与嘴 30–34；TTL 总线 1 Mbps | 已读取全组反馈并接入模型控制；负载、供电压降和运动问题需结合原始回包分析。见 [舵机实测](docs/实测记录/03-舵机实测.md)。 |
| 正点原子 MS901M IMU | 1 | UART、115200 bps；姿态、角速度与加速度 | 已接入独立采集与共享安装标定；旧接线方案不能替代当前 HAT 端口配置。见 [IMU 实测](docs/实测记录/02-IMU实测.md)。 |
| HAT 音频与扬声器 | 1 套 | AIC3104 / ALSA，配合嘴部动作播放叫声 | 已接入“嘎一下”服务动作，具体连接见 [平台记录](docs/实测记录/04-网络与观测平台.md)。 |
| IMX219 摄像头 | 1，可选 | CSI 图像采集 | e6fc56 已验证 Rust Observer 持久开关及 640×360采集、360×640旋转显示（约10fps），固定曝光与软件白平衡。见 [摄像头实测](docs/实测记录/05-摄像头实测.md)。 |
| VL53L5CX ToF | 1，可选 | I²C 多区测距 | 有历史独立通信记录；当前 ToF 服务停用 / 离线。见 [ToF 实测](docs/实测记录/06-ToF实测.md)。 |
| 主控供电、舵机供电与线束 | 按装配 | 分别核对主板输入与舵机总线供电，不能混用电压规格 | 已记录动作负载下电压下降；电池容量、线束压降和供电能力应以实际测量为准，不在此推定。见 [HAT 实测](docs/实测记录/07-HAT实测.md)。 |

## 实测摘要

实测、软件回归和仿真分别记录，完整证据见 [实测索引](docs/实测记录/README.md)。以下摘录截至 **2026-10-12** 的结果：

| 项目 | 已确认结果 | 验证范围 |
| --- | --- | --- |
| Rust 主服务部署 | ARM64 服务已运行；部署核对模型、标定、增益、BLE 身份与静态资源 | 候选与生产只读核查通过，不等于整机动作验收。 |
| 全组舵机读取 | 最近后端部署候选 998 / 999 帧完整，单帧缺 23 / 31；20 个生产快照确认卸力 | 当次部署采样结果，不保证运动中永不缺帧。 |
| Web 服务响应 | 主板本机 20 次 HTTP 快照中位 11.14ms；20 秒 WebSocket 连续接收，最大间隔约 40ms | 本机 loopback 测量，不是现场浏览器端到端延迟。 |
| 网页数据量 | 相同主题展示订阅调整后约 198.5 → 103.8KB/s，减少 47.7%，姿态保留 50Hz | 两次 20 秒本机测量；硬件采集与模型保护频率不变。 |
| 现场 Wi-Fi | 网关延迟 2～109ms；日志存在反复断开、跨接入点重新关联和频段引导通知 | 网络掉线仍待解决；网页重连优化不能修复无线关联本身。 |
| 运动与技能 | 行走、坐站、起身、拾取等控制入口和诊断已接入 | 倒地起身、部分坐站 / 方向效果仍需实机验证，不能用模型数值一致或仿真通过代替运动结果。 |

最近相关证据：[网络与网页核查](docs/实测记录/附件/平台/2026-10-12/web-link/README.md) · [后端部署](docs/实测记录/附件/平台/2026-10-12/device-links-deploy/README.md)。历史采集基准保留在实测文档中，不用于描述当前所有路径的实时性能。

## 本地开发

需要 Linux / WSL、Rust 工具链，以及 Node.js 22.12+。生产 BLE 使用 Linux BlueZ。ONNX 推理需安装匹配的原生 ONNX Runtime，并设置 `ORT_DYLIB_PATH`。

启动隔离模拟服务：

```bash
cd backend-rust
MICRODUCK_SOURCE=simulation \
MICRODUCK_BLE_ENABLED=0 \
MICRODUCK_BIND=127.0.0.1:8877 \
cargo run --locked --bin microduck-observer
```

另一个终端启动网页：

```bash
cd frontend
npm ci
npm run dev
```

打开 `http://127.0.0.1:5173`，连接 API `http://127.0.0.1:8877`。模拟数据有明确来源标识，不连接实物总线。生产构建的 `frontend/dist/` 由主服务直接提供，默认部署 Web 端口为 `8877`。

常用检查：

```bash
cd frontend
npm test
npm run build
```

```bash
cd backend-rust
cargo test --locked --bins
cargo build --release --locked --bins
```

外部模型 fixture、原生推理库和实机测试有独立环境要求；详细配置见 [Rust 后端](backend-rust/README.md)、[协议](protocol/README.md) 和 [当前工具](tools/README.md)。

## 部署与目录

发布流程见 [Rust 部署](deploy/RUST.md)。后端更新使用 `tools/deploy-runtime.py`；网页独立发布使用 `tools/deploy-frontend.py`；Wi-Fi / 电源辅助迁移使用 `tools/deploy-service-rust.py`。构建与候选验证完成后，确认机器人空闲、15 个舵机卸力再部署；安装器保留现有配置并验证回滚来源。

| 目录 | 内容 |
| --- | --- |
| `backend-rust/src/` | HTTP / WS / BLE、遥测、串口控制、模型执行、共享标定与故障诊断 |
| `backend-rust/src/bin/` | Wi-Fi 和电源权限辅助程序 |
| `frontend/src/` | Web 页面、连接状态、3D 模型、图表与实机控制组件 |
| `models/` | ONNX 权重及观测顺序、来源和执行合同 metadata |
| `deploy/`、`tools/`、`scripts/` | 发布、回滚、只读测量及分析工具 |
| `protocol/` | 消息格式与接口约定 |
| `docs/实测记录/` | 按硬件与主题维护的实物记录、故障分析及原始证据 |

## 许可与资源来源

平台代码采用 [Apache-2.0](LICENSE)。机器人外形与部分策略资源来自公开项目，平台重构与资源来源分别记录：

- 3D 网格与模型描述的来源和转换说明见 [模型 NOTICE](frontend/public/model/NOTICE.md)，保留随附许可证。
- 当前部分策略权重来自 [kissqy/Microduck-kissqy](https://github.com/kissqy/Microduck-kissqy)，具体提交、权重哈希、观测合同和执行配置以 `models/*.metadata.json` 为准；自行训练的权重也在对应 metadata 中区分。

接入资源不代表本项目训练或原创全部模型；具体模型文件名兼容历史接口，不用于判断当前权重版本。上游资源的许可和署名随资源保留。

## KiCad design hardware/dxl_hub/upstream-14b6e768a3e9/dxl_hub.kicad_pcb

File hardware/dxl_hub/upstream-14b6e768a3e9/README.md:

# "dxl_hub" 电力与数据分发板子

> "dxl_hub" 固定在机器鸭身体中舵机上方的板子。用于把电池电力分配到左右腿、头部和IMU。对单总线串口数据信号进行合并。

 - 根据需要焊接飞特1910舵机接口或XL330舵机接口，二选一。
 - 三个焊接在背面（两腿+IMU），一个正面（脖子）。
 - 物料参考型号：
   - XL330用：B3B-EH-A(LF)(SN)，立式
   - 飞特1910用：AMP175778/8283/A2007WV-3P，立式
   - 螺丝使用如下规格：

## 其他信息
 - 使用KiCAD 9设计。

Board: 2 copper layers, 22.3 x 28.2 mm, 12 parts (6 on the bottom side), 3 nets.

Parts:
C1: 1000uF/10V固态; CAP-TH_BD8.0-P3.50-D0.5-FD
CN1, CN3, CN5, CN7: B3B-EH-A (LF)(SN); CONN-TH_B3B-EH-A-LF-SN
CN2, CN4, CN6, CN8: B3B-PH-K-S(LF)(SN); CONN-TH_B3B-PH-K-S
J1, J2: 1.8mm螺丝孔; pad
J3: pad-2(thru)

Connections:
+BATT: C1.1, CN1.2, CN2.2, CN3.2, CN4.2, CN5.2, CN6.2, CN7.2, CN8.2, J3.1
/DATA: CN1.3, CN2.1, CN3.3, CN4.1, CN5.3, CN6.1, CN7.3, CN8.1
GND: C1.2, CN1.1, CN2.3, CN3.1, CN4.3, CN5.1, CN6.3, CN7.1, CN8.3, J3.2

## KiCad design hardware/banana_pcb/upstream-14b6e768a3e9/banana_pcb.kicad_pcb

File hardware/banana_pcb/upstream-14b6e768a3e9/README.md:

# "banana_pcb" 电池转接板

> "banana_pcb"固定在电池上方，用于转接电池电力的输出到其他板子

- **推荐连接器尺寸**：2.5mm香蕉头PCB连接器13mm，尾部1.5mm（参考型号U6068）
- **引出导线不要太细，正常运行电流3-5A**

## 其他信息
 - 使用KiCAD 9设计.

Parts:
J1, J2: banana_pin
J3: pad-2(surf)

Connections:
unnamed: J1.1, J3.1
unnamed: J2.1, J3.2

Board: 2 copper layers, 39.2 x 6.8 mm, 3 parts (0 on the bottom side), 2 nets.

## KiCad design hardware/imu_to_dxl/upstream-14b6e768a3e9/imu_to_dxl.kicad_pcb

File hardware/imu_to_dxl/README.md:

# imu_to_dxl — 身体姿态传感器／IMU转舵机协议板

当前归档：[上游原始资料](upstream-14b6e768a3e9/README.md)，导入日期：2026-11-02。

来源：[jyg9/microduck-community-kit](https://github.com/jyg9/microduck-community-kit/tree/14b6e768a3e97a05e437cf2a17efa3dfd926f648/hardware/imu_to_dxl)，提交 `14b6e768a3e97a05e437cf2a17efa3dfd926f648`。

保留原有目录结构、KiCad工程、PCB、原理图、生产文件、图片及 LICENCE.txt；文件清单及 SHA256 见 [provenance.json](provenance.json)。后续修改另存版本。

验证状态：复制文件逐一哈希核对、ZIP CRC校验通过；未进行本地CAD检查、装配或实物验证。此次仅归档，几何、电气与元数据均未改动。

IMU 对应固件仍在[上游 firmware/v1](https://github.com/jyg9/microduck-community-kit/tree/14b6e768a3e97a05e437cf2a17efa3dfd926f648/firmware/v1)，本次仅复制硬件目录。

Parts:
C1: 100p; C0402; LCSC Part C106200
C2, C7, C8, C9, C12, C13, C14, C15, C16, C18, C19: 100nF/16V; C0402; LCSC Part C1525
C5: 22uF/6.3V; C0603; LCSC Part C59461
C6: 10uF/50V; C0805; Manufacturer Part CL21A106KBYQNNE; LCSC Part C2932476
C10, C11, C17: 20pF/50V; C0402; LCSC Part C107000
C20, C21: 1uF/10V; C0402; LCSC Part C106254
C22: 1nF/50V; C0402; LCSC Part C106205
CN1: B3B-EH-A(LF)(SN); CONN-TH_B3B-EH-A-LF-SN; not fitted
CN2: AMP175778/8283/A2007WV-3P; CONN-TH_B3B-PH-K-S; not fitted
D1: SMAJ36A; SMA_L4.4-W2.6-LS5.0-RD; LCSC Part C353452
D2: 5V ESD; SOD-323_L1.7-W1.3-LS2.5-BI; LCSC Part C19224
F1: PTC(40R); F0603; Manufacturer Part JK-SMD0603-001; LCSC Part C2687114
H1, H3: LAIL-PZ2.54-4P-L; pad-4; Manufacturer Part LAIL-PZ2.54-4P-L; LCSC Part C54950602; not fitted
H2: PZ254V-11-05P; pad-5; Manufacturer Part PZ254V-11-05P; LCSC Part C492404; not fitted
J1, J2, J3, J4: 1.8mm螺丝孔; pad; not fitted
L1: 10uH/920mA; IND-SMD_L3.0-W3.0_SWPA3010S; Manufacturer Part SWPA3015S100MT; LCSC Part C45403
LED1: GL0603UG01; LED0603-RD; Manufacturer Part GL0603UG01; LCSC Part C51933293
Q1: MMBT3906; SOT-23; LCSC Part C727128
R1: 75K; R0402; LCSC Part C144737
R2, R10, R11, R12, R13, R17, R18, R21, R22, R23, R24, R25, R26: 51R; R0402; LCSC Part C137960
R3: 100K; R0402; LCSC Part C25741
R4: 30K; R0402; LCSC Part C25776; not fitted
R5: 0R; R0603; LCSC Part C21189
R6: 24K; R0402; LCSC Part C138026
R7, R8, R15, R16, R19: 10K; R0402; LCSC Part C25744
R9, R32: 0R; R0402; LCSC Part C60485
R14, R34: 1K; R0402; LCSC Part C11702
R20: 51R; R0402; LCSC Part C137960; not fitted
R27, R28, R30: 10k; R0402; LCSC Part C25744
R29: 20k; R0402; LCSC Part C25765
R31: 100k; R0402; LCSC Part C25741
R33: 0R; R0402_Jumper; LCSC Part C60485; not fitted
R35: 1M; R0402; LCSC Part C26083
U1: ETA2845S2G_C22362741; SOT-23-6_L2.9-W1.6-P0.95-LS2.8-BR; Manufacturer Part ETA2845S2G; LCSC Part C22362741
U2: GD32F303CCT6; LQFP-48_L7.0-W7.0-P0.50-LS9.0-BL; Manufacturer Part GD32F303CCT6; LCSC Part C116151
U3: LSM6DSV16XTR; LGA-14_L3.0-W2.5-P0.50-BR; Manufacturer Part LSM6DSV16XTR; LCSC Part C5267406
U4: SN74LVC1G126DBVR; SOT-23-5; LCSC Part C46472327
U5: SN74LVC1G125DBV; SOT-23-5; LCSC Part C3040625
U6: ME6211C18M5G-N; SOT-23-5_L3.0-W1.7-P0.95-LS2.8-BR; Manufacturer Part ME6211C18M5G-N; LCSC Part C236671
X1: XL2EL89CSI-111YLC-12M; CRYSTAL-SMD_4P-L3.2-W2.5-BL; Manufacturer Part XL2EL89CSI-111YLC-12M; LCSC Part C5280576

Connections:
+1.8VA: C21.2, R32.1, U6.5 (VOUT)
+3.3V: C1.2, C5.2, C7.2, C12.1, C13.2, C14.2, C16.2, C18.2, C19.2, C20.2, H1.1, H2.2, L1.2, Q1.2 (E), R1.2, R7.1, R8.2, R9.2, R15.2, R16.2, R20.2, R27.2, R30.2, R31.2, R33.2, U2.1 (VBAT), U2.24 (VDD_1), U2.36 (VDD_2), U2.48 (VDD_3), U3.5 (Vdd_IO), U4.5 (VCC), U5.5 (VCC), U6.1 (VIN), U6.3 (CE)
+BATT: C6.2, CN1.2, CN2.2, D1.1 (K), H3.4, R3.2, U1.5 (IN)
/DATA: CN1.3, CN2.1, F1.1
/DATA1: R5.2, R31.1, U4.4, U5.2
/DEBUG_LED: LED1.2 (A), U2.41 (PB5)
/DEBUG_RX: R7.2, R10.1, U2.43 (PB7)
/DEBUG_TX: R11.1, U2.42 (PB6)
/GD_OSCIN: C10.2, R35.2, U2.5 (PD0-OSCIN), X1.1
/GD_OSCOUT: C11.2, R35.1, U2.6 (PD1-OSCOUT), X1.3
/GD_RST: C8.2, R8.1, R14.1, U2.7 (NRST)
/GD_SWDCLK: R12.1, R15.1, U2.37 (PA14)
/GD_SWDIO: R13.1, R16.1, U2.34 (PA13)
/IMU_INT1: R25.2, U3.4 (INT1)
/IMU_INT2: R26.2, U3.9 (INT2)
/IMU_SPI_CLK: R22.2, U3.13 (SCL)
/IMU_SPI_CS: C17.2, R21.2, U3.12 (CS)
/IMU_SPI_MISO: R23.2, U3.1 (SDO/SA0)
/IMU_SPI_MOSI: R24.2, U3.14 (SDA)
/PA2_USART1_TX: R27.1, R28.1, U2.12 (PA2), U4.2
/PA3_USART1_RX: R30.1, U2.13 (PA3), U5.4
/PA4_SPI0_NSS: R21.1, U2.14 (PA4)
/PA5_SPI0_SCK: R22.1, U2.15 (PA5)
/PA6_SPI0_MISO: R23.1, U2.16 (PA6)
/PA7_SPI0_MOSI: R24.1, U2.17 (PA7)
/PB0: R25.1, U2.18 (PB0)
/PB1: R26.1, U2.19 (PB1)
/TXD_EN: C22.2, Q1.3 (C), R29.2, U4.1, U5.1
/USB_DM: H3.3, R17.2
/USB_DP: H3.2, R18.2
GND: C5.1, C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, C12.2, C13.1, C14.1, C15.1, C16.1, C17.1, C18.1, C19.1, C20.1, C21.1, C22.1, CN1.1, CN2.3, D1.2 (A), D2.1, H1.2, H2.3, H3.1, R4.2, R6.1, R19.1, R29.1, R34.1, U1.2 (GND), U2.8 (VSSA), U2.23 (VSS_1), U2.35 (VSS_2), U2.47 (VSS_3), U3.2 (SDx/AH1/Qvar1), U3.3 (SCx/AH2/Qvar2), U3.6 (GND), U3.7 (GND), U4.3 (GND), U5.3 (GND), U6.2 (VSS), X1.2 (GND), X1.4 (GND)
unnamed: C2.1, R2.2
unnamed: D2.2, F1.2, R5.1
unnamed: H1.3, R10.2
unnamed: H1.4, R11.2
unnamed: H2.1, R14.2
unnamed: H2.4, R13.2
unnamed: H2.5, R12.2
unnamed: LED1.1 (K), R34.2
unnamed: Q1.1 (B), R28.2
unnamed: R2.1, U1.1 (BST)
unnamed: R3.1, R4.1, U1.4 (EN)
unnamed: C1.1, R1.1, R6.2, U1.3 (FB)
unnamed: C2.2, L1.1, U1.6 (SW)
unnamed: R19.2, R33.1, U2.44 (BOOT0)
unnamed: R17.1, U2.32 (PA11)
unnamed: R18.1, U2.33 (PA12)
unnamed: C9.2, R9.1, U2.9 (VDDA)
unnamed: C15.2, R20.1, R32.2, U3.8 (Vdd)

Notes on the sheet:
Debug
二选一，手工焊接
SWD
USB Download
USB Download Switch

Board: 2 copper layers, 27.1 x 30.2 mm, 77 parts (0 on the bottom side), 49 nets.

## KiCad design hardware/power-hub/revN-eco1/source/kicad/microduck-power-hub.kicad_pcb

File hardware/power-hub/README.md:

# 舵机电源 Hub

当前方案：**[Rev N / ECO1：无开关＋C1去耦电容](revN-eco1/README.md)**。采购为三个CJT A2007WV-3P（C225336）座和一颗10µF/25V/X7R、1206电容；电容具体品牌可按规格替代。

- [最新立创EDA专业版工程](revN-eco1/eda/MicroDuck-Hub-RevN-Cap-ECO1.epro)
- [采购BOM](revN-eco1/bom/BOM.csv)
- [源板Gerber打样包](revN-eco1/manufacturing/MicroDuck-Hub-RevN-Gerber.zip)
- [完整归档资料包](packages/MicroDuck-Hub-RevN-ECO1-Complete.zip)
- [效果图](revN-eco1/previews/pcb-3d.png)

此处“当前版本”指用户确认的设计方案；**立创客户端新预览/DRC和实物验证仍待完成**。导入前阅读版本说明，避免更新时删除安装孔或覆盖GND线宽规则。

今后的电源Hub修改从本目录继续，新增版本时保留旧版并更新当前入口。2026-10-20以前的A–N生成过程、开关版及诊断中间稿留在 `microduck-rl/hardware/power-hub/` 历史来源目录；不再向那里新增正式版本。HAT相关实测见 [07-HAT实测](../../docs/实测记录/07-HAT实测.md)。

Parts:
C1: 10uF_25V_X7R; C_1206_3216Metric
J1: BAT_PLUS_LEFT; SolderInput_SMD_D3
J2: A2007WV-3P_LEFT; CJT_A2007WV-3P_C225336; MPN A2007WV-3P; LCSC C225336
J3: A2007WV-3P_HEAD; CJT_A2007WV-3P_C225336; MPN A2007WV-3P; LCSC C225336
J4: A2007WV-3P_RIGHT; CJT_A2007WV-3P_C225336; MPN A2007WV-3P; LCSC C225336
J5: BAT_MINUS_RIGHT; SolderInput_SMD_D3

Connections:
DATA: J2.3, J3.3, J4.3
GND: C1.2, J2.1, J3.1, J4.1, J5.1
VBAT: C1.1, J1.1, J2.2, J3.2, J4.2

Board: 2 copper layers, 40.0 x 22.0 mm, 8 parts (0 on the bottom side), 3 nets.

Other parts of the board:
H1, H2: Case_mount_clearance_2.2_thread_unverified

File hardware/power-hub/revN-eco1/bom/BOM-候选匹配.csv:

位号,每板数量,型号/规格,封装,品牌,立创编号,状态
"J2,J3,J4",3,A2007WV-3P,AMP2.0 3P,CJT,C225336,原选型
C1,1,CGA1206X7R106K250NT;10uF ±10% 25V X7R,1206,HRE(芯声),C6119987,截图候选，名义规格匹配，未下单
